## src/examples/hop_motor_control/Kconfig
```kconfig
menuconfig EXAMPLES_HOP_MOTOR_CONTROL
	bool "hop_motor_control"
	default n
	---help---
		Enable support for hop_motor_control
```
